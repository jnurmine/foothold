# SPDX-License-Identifier: MIT

# Overwrite some of the default base-files with our own stuff
FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"
