# SPDX-License-Identifier: MIT
PACKAGECONFIG_remove = "x11"
